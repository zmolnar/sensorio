/**
 * @file main.cpp
 * @brief
 */

/*****************************************************************************/
/* INCLUDES                                                                  */
/*****************************************************************************/
#include <iostream>

#include "../../sensorio/src/kalmanfilter/matrix.h"

/*****************************************************************************/
/* DEFINED CONSTANTS                                                         */
/*****************************************************************************/

/*****************************************************************************/
/* TYPE DEFINITIONS                                                          */
/*****************************************************************************/

/*****************************************************************************/
/* MACRO DEFINITIONS                                                         */
/*****************************************************************************/

/*****************************************************************************/
/* DEFINITION OF GLOBAL CONSTANTS AND VARIABLES                              */
/*****************************************************************************/

/*****************************************************************************/
/* DECLARATION OF LOCAL FUNCTIONS                                            */
/*****************************************************************************/

/*****************************************************************************/
/* DEFINITION OF LOCAL FUNCTIONS                                             */
/*****************************************************************************/

/*****************************************************************************/
/* DEFINITION OF GLOBAL FUNCTIONS                                            */
/*****************************************************************************/
int main(int argc, char **argv)
{
  Matrix a = Matrix(3, 3);
  Matrix b = Matrix(3, 3);

  for (size_t i = 0; i < a.rowCount(); ++i) {
    for (size_t j = 0; j < a.columnCount(); ++j) {
      a(i, j) = 1;
    }
  }

  std::cout << a;

  int num = 0;
  for (size_t i = 0; i < b.rowCount(); ++i) {
    for (size_t j = 0; j < b.columnCount(); ++j) {
      b(i, j) = ++num;
    }
  }

  Matrix m = Matrix(3, 3);
  m(0, 0)  = 6;
  m(0, 1)  = 15;
  m(0, 2)  = 55;

  m(1, 0) = 15;
  m(1, 1) = 55;
  m(1, 2) = 225;

  m(2, 0) = 55;
  m(2, 1) = 225;
  m(2, 2) = 979;

  std::cout << "m" << std::endl << m << std::endl;
  std::cout << "m.sqrt" << std::endl << m.sqrt() << std::endl;


  // Matrix m = Matrix(4,4);
  // m(0,0) = 5;
  // m(0,1) = -2;
  // m(0,2) = 2;
  // m(0,3) = 7;

  // m(1,0) = 1;
  // m(1,1) = 0;
  // m(1,2) = 0;
  // m(1,3) = 3;

  // m(2,0) = -3;
  // m(2,1) = 1;
  // m(2,2) = 5;
  // m(2,3) = 0;

  // m(3,0) = 3;
  // m(3,1) = -1;
  // m(3,2) = -9;
  // m(3,3) = 4;

  // std::cout << "Matrix m:";
  // std::cout << m;
  // std::cout << std::endl;

  // std::cout << "m.T() = " << m.T() << std::endl;

  // std::cout << "m.det() = " << m.det() << std::endl;

  // std::cout << std::endl;
  // std::cout << "m.adj()" << std::endl;
  // std::cout << m.adj();

  // std::cout << std::endl;
  // std::cout << "m.inv()" << std::endl;
  // std::cout << m.inv();

  return 0;
}

/****************************** END OF FILE **********************************/
